ORG 0000H

; MOVE NUMBERS INTO THEIR MEMORY ADDRESSES
MOV 41H, #08H
MOV 42H, #03H
MOV 43H, #01H
MOV 44H, #06H
MOV 45H, #09H
MOV 46H, #07H
MOV 47H, #02H
MOV 48H, #04H

MOV R5 , #08H ; COUNTER FOR OUTER LOOP

START1:
MOV R0 , #41H; INDIRECT
MOV R1 , #42H; INDIRECT
MOV R4 , #07H; COUNTER FOR INNER LOOP

START:
MOV A , @R0
MOV B , @R1

CJNE A,B,LOOP
LOOP:
JNC LOOP1
MOV @R0,B
MOV @R1,A

LOOP1:

INC R0
INC R1

DJNZ R4 , START
DJNZ R5 , START1

END

